# IAR project Meter.ewp, settings and files
configuration Meter50F103 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_MD; METER50
  ICCARM.CCIncludePath2: Source\Sys\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: Meter.hex
  ILINK.IlinkOutputFile: Meter.out
  ILINK.IlinkIcfFile: D:\Projects\NSM_lab\Audio\E-004\Meter\Firmware\Meter.icf
  ILINK.IlinkExtraOptions: --basic_heap
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Meter50F100 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F100x8 ST STM32F100x8
  ICCARM.CCDefines: STM32F10X_MD_VL; METER50
configuration Meter40F100 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F100x8 ST STM32F100x8
  ICCARM.CCDefines: STM32F10X_MD_VL; METER40
configuration Meter35F100 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F100x8 ST STM32F100x8
  ICCARM.CCDefines: STM32F10X_MD_VL; METER35
  group App
    Source/: adc.cpp bright.cpp control.cpp display.cpp eeprom.cpp i2csw.cpp keyboard.cpp main.cpp port.cpp process.cpp sreg.cpp systimer.cpp wake.cpp wakeport.cpp
  group Sys
    Source/Sys/: startup_stm32f10x_md_vl.s stm32f10x.h
